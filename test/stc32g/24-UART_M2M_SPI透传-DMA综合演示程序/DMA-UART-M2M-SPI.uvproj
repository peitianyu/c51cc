# Keil uVision project DMA-UART-M2M-SPI.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: DMA-UART-M2M-SPI +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: isr.asm main.c STC32G_DMA.c STC32G_DMA_Isr.c STC32G_GPIO.c STC32G_NVIC.c STC32G_SPI.c STC32G_SPI_Isr.c STC32G_UART.c STC32G_UART_Isr.c

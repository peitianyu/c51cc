# Keil uVision project I2C_Slave_INT.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: I2C_Slave_INT +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c STC32G_GPIO.c STC32G_I2C.c STC32G_I2C_Isr.c STC32G_NVIC.c STC32G_Soft_I2C.c STC32G_Timer.c STC32G_Timer_Isr.c STC32G_UART.c STC32G_UART_Isr.c

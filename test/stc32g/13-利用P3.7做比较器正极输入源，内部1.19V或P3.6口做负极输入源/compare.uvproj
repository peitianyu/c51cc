# Keil uVision project compare.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: compare +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c STC32G_Compare.c STC32G_Compare_Isr.c STC32G_GPIO.c STC32G_NVIC.c
